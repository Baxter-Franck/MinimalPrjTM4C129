# Keil uVision project MinimalPrjTM4C129.uvproj, settings and files
target Minimal_TM4C129 (ARM-ADS)
  device: TM4C1294KCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x00000000-0x0007FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: minimal_tm4c129
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_TM4C1294KCPDT __USE_C99_MATH
  c include: .\MPD_Tiva\driverlib;.\MPD_Tiva\inc;.\App;.\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group app
    ./: startup_TM4C129.s
    ./App/: main.c
  group drivers
    ./Drivers/: ddi_uart.c ioexp.c
  group lib
    ./MPD_Tiva/driverlib/: adc.c can.c cpu.c eeprom.c flash.c gpio.c i2c.c interrupt.c pwm.c ssi.c sysctl.c systick.c timer.c uart.c uartstdio.c
